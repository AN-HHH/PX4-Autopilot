## src/examples/my_controller/Kconfig
```kconfig
menuconfig EXAMPLES_my_controller
	bool "my_controller"
	default n
	---help---
		Enable support for my_controller
```
